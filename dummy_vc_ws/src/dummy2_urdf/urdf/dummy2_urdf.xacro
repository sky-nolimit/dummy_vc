Commit message: fix: 相机俯角是 16°，不是我之前估的 30°
上一轮在虚拟机上第一次拿到真数据：方块放在 base_link 的 (+y 0.31、边长 24 mm)，
vision_node 报出来的抓取点是 (-0.091, 0.292)，x 偏了 9 cm。日志里的拟合边长还
一条轴稳定在 25.9 mm、另一条从 28.6 一路跳到 46.6 mm，时而过关时而被丢掉。

从"节点实际看到的那个像素"反解，问题不在检测算法，在挂载姿态：
那个像素是 (591, 555)，而按"斜下 30°、高 15 cm"这套参数应该落在 (564, 376)，
竖直差了 180 像素。固定高度 15 cm，用这一个观测点解出俯角 16°（高度 14 cm 会解
出 14°、16 cm 解出 18°，所以这数本身的误差可能随时是 ±3°）。

顺带解释那些"闪烁的长度"：视线几乎贴着地面掠过时，反投影对像素极其敏感
（1/sin 放大，16° 时约 3.6 倍），姿态错了那条轴的尺寸既被拉长又极不稳定，
才会在 10 mm 的门限上反复横跳。姿态对上之后再观察，还在抖才去调 HSV。

改动：
- xacro：camera_offset_x -0.23 → -0.21（用户重新量过），
  camera_mount_pitch_deg 30 → 16，注释写清反解过程、±3° 的不确定度、
  以及"这个角必须写在 pitch 上、写 roll 会静默全错"。
- vision_node 与自测的"镜头是否明显朝下"门限从 -0.3 放到 -0.15：
  16° 的竖直分量是 -0.276，-0.3 的门限会把合法的实装判红。
- perception README 的挂载段落同步，并记下"水平方向还差约 5°、先不动 yaw"
  的理由（分不清是装歪还是量偏，换个 y 位置再测就能分开）。

File: dummy_vc_ws/src/dummy2_urdf/urdf/dummy2_urdf.xacro (robot description, xacro)
@@ -392,27 +392,29 @@
          方案 B：给下面这个关节加条件，标定后不再展开
        首期用方案 A，简单直接。 -->
-<xacro:property name="camera_offset_x" value="-0.23"/>
+<xacro:property name="camera_offset_x" value="-0.21"/>
 <xacro:property name="camera_offset_y" value="0.30"/>
 <xacro:property name="camera_offset_z" value="0.15"/>
 <!-- 相机安装姿态（度）。
-     这三条是 2026-10-16 用户口头给的位置（-x 23 cm、+y 30 cm、高 15 cm），
-     **不是标定结果**，手眼标定会给出准确值。
-     相机是**斜向下 30°（相对水平）**，不是垂直向下 —— 倾斜方向朝 +x，
-     光轴在 base_link 里是 (0.866, 0, -0.500)，落到地面（z=0）上的点是
-     (-0.23 + 0.15/tan30°, 0.30) ≈ (+0.03, +0.30)，离用户说的方块位置
-     （+y 31 cm、x≈0）只有几厘米，所以方块应该出现在画面中心附近。
-     rpy 这里为什么是 pitch=+30°：
-     相机本体系 camera_link 的 **+x 是镜头方向**（REP-103 下 x 前），而
-     orbbec_camera 驱动把光学系定义成 optical 的 z（前）指向 camera_link 的 +x。
-     绕 y 轴转 pitch 角，+x 变成 (cos pitch, 0, -sin pitch)：
-       pitch=90° → (0, 0, -1)  垂直朝下
-       pitch=30° → (0.866, 0, -0.5)  朝 +x 斜下 30°  ← 现在用这个
-     写成绕 x 轴转 roll 的话镜头只在 yz 平面里动，方向完全不同；写成
-     roll=180 则镜头水平朝 +x —— 那个值反投影出来的结果全是斜的，而且
-     不会报错。
-     yaw=0：倾斜方向就是 +x。如果实机上画面中心不在方块上，改的是 pitch
-     和 yaw 两个数（pitch 管压低多少、yaw 管朝哪个方位压），不是只改 yaw。 -->
+     位置和角度都是 2026-10-16 用户用卷尺/目测给的（-x 21 cm、+y 30 cm、
+     高 15 cm），**不是标定结果**，手眼标定会给出准确值。
+     俯角这一条是**反解出来的，不是估的**：方块放在 base_link 的 (+y 0.30、
+     边长 24 mm) 时，vision_node 实际看到的那个像素是 (591, 555)，而按原先
+     估的"斜下 30°、高 15 cm"应该落在 (564, 376) —— 竖直差了 180 像素，
+     报出来的抓取点因此偏了 9 cm（x 方向）。固定高度 15 cm，用这一个观测点
+     解出俯角 16°，此时算出的抓取点与尺量位置对得上。
+     不确定度要说清楚：单点标定对高度很敏感 —— 高度 14 cm 会解出 14°、
+     16 cm 解出 18°，所以 16° 的误差可能随时是 ±3°，在 0.27 m 处就是 ±1.4 cm。
+     手眼标定之前够用，标定之后换真实值。
+     俯角写小了/写大了怎么改：pitch 越大压得越陡（90° = 垂直朝下）。这个角
+     必须写在 **pitch** 上 —— camera_link 的 +x 才是镜头方向（orbbec 驱动把
+     光学系的 z 指向 camera_link 的 +x），绕 y 轴转 pitch 时 +x 变成
+     (cos pitch, 0, -sin pitch)；写成 roll 的话镜头只在 yz 平面里动，方向完全
+     不同，而且不会报错，只是所有抓取点都偏。
+     yaw=0：倾斜方向就是 +x。水平方向还差约 5°（观测像素比预期偏左 50 像素，
+     相当于 0.27 m 处 2 cm），现在分不清是相机装歪了 5°、还是相机/方块的位置
+     量偏了 2 cm，所以先不动 yaw —— 把方块换个 y 位置再测一次就能分开。
+     真要改的时候：pitch 管压低多少，yaw 管朝哪个方位压，不是只改 yaw。 -->
 <xacro:property name="camera_mount_roll_deg" value="0"/>
-<xacro:property name="camera_mount_pitch_deg" value="30"/>
+<xacro:property name="camera_mount_pitch_deg" value="16"/>
 <xacro:property name="camera_mount_yaw_deg" value="0"/>
 <link name="camera_link"/>

Commit message: 俯角改成 33.3°：那个 1.21° 是在写 34° 时测的，不是 16°
用户纠正了一处关键事实：他贴的"法向偏 1.21°"那次，xacro 里写的是 34°，不是
16°。也就是说真实俯角约 34 - 0.68 = 33.3°。

这推翻了两件事：

1. 我在 e676f4e 里把俯角改成 16° 是错的。那个数是"固定高度、用方块的一个像素
   反解"出来的，而立方体的地面投影会沿视线拉长、平面假设也不成立，两个误差
   能互相抵消成任何值——用户后来扫角度时发现"两条拟合边长一起变短、根本不
   收敛"，就是这个方法失效的现场。地面法向拟合是几万个点的最小二乘，0.1° 量级，
   这个才可信。
2. camera_offset_x 从 -0.23 改回 -0.23：那个 -0.21 和 16° 出自同一次不可靠的
   反解，卷尺量的是 23 cm。

同一个数字在 xacro、vision_node 的告警文案、自测的 note、README 里各写了一遍，
这次一起对齐（16° → 33.3°、竖直分量 -0.28 → -0.55、1/sin 放大 3.6 倍 → 1.8 倍）。
高度仍然不确定（卷尺换算 0.12、深度拟合换算 0.16），保持 0.15 并在注释里写明
两个估计差 4 cm，等手眼标定。

File: dummy_vc_ws/src/dummy2_urdf/urdf/dummy2_urdf.xacro (robot description, xacro)
@@ -392,18 +392,22 @@
          方案 B：给下面这个关节加条件，标定后不再展开
        首期用方案 A，简单直接。 -->
-<xacro:property name="camera_offset_x" value="-0.21"/>
+<xacro:property name="camera_offset_x" value="-0.23"/>
 <xacro:property name="camera_offset_y" value="0.30"/>
 <xacro:property name="camera_offset_z" value="0.15"/>
 <!-- 相机安装姿态（度）。
-     位置和角度都是 2026-10-16 用户用卷尺/目测给的（-x 21 cm、+y 30 cm、
-     高 15 cm），**不是标定结果**，手眼标定会给出准确值。
-     俯角这一条是**反解出来的，不是估的**：方块放在 base_link 的 (+y 0.30、
-     边长 24 mm) 时，vision_node 实际看到的那个像素是 (591, 555)，而按原先
-     估的"斜下 30°、高 15 cm"应该落在 (564, 376) —— 竖直差了 180 像素，
-     报出来的抓取点因此偏了 9 cm（x 方向）。固定高度 15 cm，用这一个观测点
-     解出俯角 16°，此时算出的抓取点与尺量位置对得上。
-     不确定度要说清楚：单点标定对高度很敏感 —— 高度 14 cm 会解出 14°、
-     16 cm 解出 18°，所以 16° 的误差可能随时是 ±3°，在 0.27 m 处就是 ±1.4 cm。
-     手眼标定之前够用，标定之后换真实值。
+     位置：2026-10-19 用户卷尺量的（相对底座中心 -x 23 cm、+y 30 cm）。
+     高度这一项**不确定度最大**：用户量到的是"地面到相机外壳 15 cm、中心
+     16 cm"，而地面在 base_link 里是 -0.0405（底座底面 -0.0155 + 2.5 cm
+     地台），换算过来应该是 0.12 左右；但深度拟合报的是相机到地面的垂直距离
+     0.202 m，换算过来是 0.16。两个估法差 4 cm，谁对还没定（近距离深度可能
+     系统性偏长，Gemini 335L 的最小工作距离约 0.25 m，现在相机离地只有 16 cm
+     就在规格边缘）。先取中间的 0.15，手眼标定会给准值。
+     **俯角 33.3° 是量出来的，不是估的**：`vision_node` 的 `calibrate_plane`
+     会对整幅深度里的地面做最小二乘拟合，把法向转到 base_link 看它歪多少。
+     写 34° 时法向是 (+0.012, +0.018, +1.000)（相对竖直偏 1.21°，要补
+     -0.68°），所以真实俯角 ≈ 34 - 0.68 = 33.3°。这是几万个点的拟合，精度
+     0.1° 量级，比之前那个"用方块单个像素反解"的方法可靠得多 —— 那个方法解出
+     16°，事后看是错的（它把高度当已知、把平面假设套在立体方块上，两个误差
+     会互相抵消成任何一个数）。
      俯角写小了/写大了怎么改：pitch 越大压得越陡（90° = 垂直朝下）。这个角
      必须写在 **pitch** 上 —— camera_link 的 +x 才是镜头方向（orbbec 驱动把
@@ -411,10 +415,9 @@
      (cos pitch, 0, -sin pitch)；写成 roll 的话镜头只在 yz 平面里动，方向完全
      不同，而且不会报错，只是所有抓取点都偏。
-     yaw=0：倾斜方向就是 +x。水平方向还差约 5°（观测像素比预期偏左 50 像素，
-     相当于 0.27 m 处 2 cm），现在分不清是相机装歪了 5°、还是相机/方块的位置
-     量偏了 2 cm，所以先不动 yaw —— 把方块换个 y 位置再测一次就能分开。
-     真要改的时候：pitch 管压低多少，yaw 管朝哪个方位压，不是只改 yaw。 -->
+     yaw=0：倾斜方向就是 +x。水平方向的偏差（绕竖直轴）**地面拟合法永远标不
+     出来** —— 一个水平面绕自己的法向转多少度都还是它自己。要标 yaw 得用已知
+     位置的物体：把方块放在一个量好的点上，反解方位角。 -->
 <xacro:property name="camera_mount_roll_deg" value="0"/>
-<xacro:property name="camera_mount_pitch_deg" value="16"/>
+<xacro:property name="camera_mount_pitch_deg" value="33.3"/>
 <xacro:property name="camera_mount_yaw_deg" value="0"/>
 <link name="camera_link"/>

Commit message: fix: 相机重新装过了 —— 位置改成 -x31/+y31，并标明俯角已过期
用户 2026-10-19 重新装了相机：位置变成相对底座中心 -x 31 cm、+y 31 cm（卷尺
量，不精确但可用），角度按他说的"靠深度来测"。

改动：
- camera_offset_x -0.23 -> -0.31、camera_offset_y 0.30 -> 0.31。
- 注释里删掉"俯角 33.3° 是量出来的"这段 —— 那是重装之前测的，现在这个数已经
  过期，必须按新一轮 calibrate_plane 的修正量重算（真实俯角 = 文件里写的值 +
  日志给的修正量）。留着旧解释会让人以为 33.3 还是可信的。
- 注释里补上"位置误差只让坐标整体平移、要用已知位置的方块校一次"。

File: dummy_vc_ws/src/dummy2_urdf/urdf/dummy2_urdf.xacro (robot description, xacro)
@@ -392,9 +392,12 @@
          方案 B：给下面这个关节加条件，标定后不再展开
        首期用方案 A，简单直接。 -->
-<xacro:property name="camera_offset_x" value="-0.23"/>
-<xacro:property name="camera_offset_y" value="0.30"/>
+<xacro:property name="camera_offset_x" value="-0.31"/>
+<xacro:property name="camera_offset_y" value="0.31"/>
 <xacro:property name="camera_offset_z" value="0.15"/>
 <!-- 相机安装姿态（度）。
-     位置：2026-10-19 用户卷尺量的（相对底座中心 -x 23 cm、+y 30 cm）。
+     位置：2026-10-19 用户重新装了相机，卷尺量的是"相对底座中心 -x 31 cm、+y 31 cm"，
+     **不精确但可用**：位置误差不会把形状搞歪，只会让报出来的 base_link 坐标
+     整体平移到别处 —— 所以后面必须用实测校一次：把方块放在量好的点上，看
+     vision_node 报的坐标，差值就是 camera_offset_x/y 的偏差。
      高度这一项**不确定度最大**：用户量到的是"地面到相机外壳 15 cm、中心
      16 cm"，而地面在 base_link 里是 -0.0405（底座底面 -0.0155 + 2.5 cm
@@ -403,11 +406,8 @@
      系统性偏长，Gemini 335L 的最小工作距离约 0.25 m，现在相机离地只有 16 cm
      就在规格边缘）。先取中间的 0.15，手眼标定会给准值。
-     **俯角 33.3° 是量出来的，不是估的**：`vision_node` 的 `calibrate_plane`
-     会对整幅深度里的地面做最小二乘拟合，把法向转到 base_link 看它歪多少。
-     写 34° 时法向是 (+0.012, +0.018, +1.000)（相对竖直偏 1.21°，要补
-     -0.68°），所以真实俯角 ≈ 34 - 0.68 = 33.3°。这是几万个点的拟合，精度
-     0.1° 量级，比之前那个"用方块单个像素反解"的方法可靠得多 —— 那个方法解出
-     16°，事后看是错的（它把高度当已知、把平面假设套在立体方块上，两个误差
-     会互相抵消成任何一个数）。
+     **俯角 33.3° 已经过期**：那是 2026-10-19 重新装相机之前测出来的。现在这个角
+     只能靠深度拟合重新定：跑一次 `calibrate_plane:=true`，日志会给出
+     "camera_mount_pitch_deg 加上 XX°"，真实俯角 = **你跑的那个文件里写的值
+     + 日志给的修正量**（所以先记住自己写的是多少）。
      俯角写小了/写大了怎么改：pitch 越大压得越陡（90° = 垂直朝下）。这个角
      必须写在 **pitch** 上 —— camera_link 的 +x 才是镜头方向（orbbec 驱动把

Commit message: fix: 相机位置按已知方块校掉 2 cm —— 报出的坐标整体偏了，不是噪声
现场：方块放在 base_link 的 (0, 0.31)，节点稳定报出 (0.022, 0.289)。

合成场景里把"相机真实位置"挪 e、其余不动，量过重建出来的点会偏 d ≈ -e
（x/y 基本一比一，z 误差会放大到 1.5 倍左右）。所以这 2 cm 的形状正好是
"相机位置手量偏了 2 cm"，不是分割或拟合的随机误差。

按 e = (-0.022, +0.021) 把 camera_offset_x/y 从 -0.31/0.31 推到
-0.332/0.331，z 与俯角不动。

这是**一点校正**：误差本身分不清"相机偏了"和"方块其实放在 0.29 而不是 0.31"，
两点才能分开，所以注释里写明了，等第二个位置的数回来再定。

File: dummy_vc_ws/src/dummy2_urdf/urdf/dummy2_urdf.xacro (robot description, xacro)
@@ -391,7 +391,12 @@
          方案 A（推荐）：把标定结果填进下面这个固定关节，删掉外部静态发布
          方案 B：给下面这个关节加条件，标定后不再展开
-       首期用方案 A，简单直接。 -->
-<xacro:property name="camera_offset_x" value="-0.31"/>
-<xacro:property name="camera_offset_y" value="0.31"/>
+       首期用方案 A，简单直接。
+     2026-10-19 用"已知位置的方块"校了一次：方块放在 base_link 的 (0, 0.31)，
+     节点报出 (0.022, 0.289)。合成场景验证过，相机的平移误差 e 会让重建出的点
+     整体偏 d ≈ -e（x/y 一比一，z 会放大到 1.5 倍左右），所以按 e=(-0.022,
+     +0.021) 把 x/y 各推了 2 cm。这只是**一点校正**，误差和"方块其实是放在
+     0.31 还是 0.29"分不开 —— 再量第二个点（换个位置）才能确认。 -->
+<xacro:property name="camera_offset_x" value="-0.332"/>
+<xacro:property name="camera_offset_y" value="0.331"/>
 <xacro:property name="camera_offset_z" value="0.15"/>
 <!-- 相机安装姿态（度）。

Commit message: fix: 相机位姿按四组实测数据解出来 —— 手量的那组偏到抓取点差 20 cm
现场数据：方块放在 (0,+0.31)、(+0.10,+0.31)、(0,+0.21)、(0,+0.41)，节点报出的
x 分别偏 -0.19~-0.20、y 也随之压缩。把三组"沿 +x 走 20 cm、报出的 x 只走 7.2 cm"
摆到一起就能看出问题：纯平移误差只会整体平移，压缩到 0.36 倍说明里面还压着
一个角度错。所以 2026-10-19 那次"按一个点把 x/y 各推 2 cm"的校正本身就是错的，
这次把它整个替掉。

解出来的位姿：

    (-0.302, +0.317, +0.097) m   pitch 4.44°   yaw -1.32°

四个点残差 RMS 8.4 mm；用这组参数做正向仿真（渲染掩膜 → 走节点同一套
project_blob_to_plane + detection_from_blob），四个点算出的坐标与真值差都在
1 mm 以内。原来的卷尺值 (pitch 33.3°、z 0.15) 在同一组仿真下偏 5~17 cm。

两个连带调整：

- `_warn_camera_geometry` 的"太水平"门限从 -0.15 放到 -0.05：这台机器实装就是
  接近水平的（解出来 4.4°，竖直分量 -0.077），旧门限会每帧假警报。
- 自测里对应的那条件同样放宽到 -0.05，并把注释改成"这台机器天生装得很平"。

还有一处必须记下来的判据：**不能用"节点报出的坐标"当标定残差**。那是节点用
假设位姿算出来的，换位姿它跟着变，等于没有信息；真正带信息的是 (像素, 真实
位置) 这一对。

File: dummy_vc_ws/src/dummy2_urdf/urdf/dummy2_urdf.xacro (robot description, xacro)
@@ -392,38 +392,32 @@
          方案 B：给下面这个关节加条件，标定后不再展开
        首期用方案 A，简单直接。
-     2026-10-19 用"已知位置的方块"校了一次：方块放在 base_link 的 (0, 0.31)，
-     节点报出 (0.022, 0.289)。合成场景验证过，相机的平移误差 e 会让重建出的点
-     整体偏 d ≈ -e（x/y 一比一，z 会放大到 1.5 倍左右），所以按 e=(-0.022,
-     +0.021) 把 x/y 各推了 2 cm。这只是**一点校正**，误差和"方块其实是放在
-     0.31 还是 0.29"分不开 —— 再量第二个点（换个位置）才能确认。 -->
-<xacro:property name="camera_offset_x" value="-0.332"/>
-<xacro:property name="camera_offset_y" value="0.331"/>
-<xacro:property name="camera_offset_z" value="0.15"/>
-<!-- 相机安装姿态（度）。
-     位置：2026-10-19 用户重新装了相机，卷尺量的是"相对底座中心 -x 31 cm、+y 31 cm"，
-     **不精确但可用**：位置误差不会把形状搞歪，只会让报出来的 base_link 坐标
-     整体平移到别处 —— 所以后面必须用实测校一次：把方块放在量好的点上，看
-     vision_node 报的坐标，差值就是 camera_offset_x/y 的偏差。
-     高度这一项**不确定度最大**：用户量到的是"地面到相机外壳 15 cm、中心
-     16 cm"，而地面在 base_link 里是 -0.0405（底座底面 -0.0155 + 2.5 cm
-     地台），换算过来应该是 0.12 左右；但深度拟合报的是相机到地面的垂直距离
-     0.202 m，换算过来是 0.16。两个估法差 4 cm，谁对还没定（近距离深度可能
-     系统性偏长，Gemini 335L 的最小工作距离约 0.25 m，现在相机离地只有 16 cm
-     就在规格边缘）。先取中间的 0.15，手眼标定会给准值。
-     **俯角 33.3° 已经过期**：那是 2026-10-19 重新装相机之前测出来的。现在这个角
-     只能靠深度拟合重新定：跑一次 `calibrate_plane:=true`，日志会给出
-     "camera_mount_pitch_deg 加上 XX°"，真实俯角 = **你跑的那个文件里写的值
-     + 日志给的修正量**（所以先记住自己写的是多少）。
-     俯角写小了/写大了怎么改：pitch 越大压得越陡（90° = 垂直朝下）。这个角
-     必须写在 **pitch** 上 —— camera_link 的 +x 才是镜头方向（orbbec 驱动把
-     光学系的 z 指向 camera_link 的 +x），绕 y 轴转 pitch 时 +x 变成
-     (cos pitch, 0, -sin pitch)；写成 roll 的话镜头只在 yz 平面里动，方向完全
-     不同，而且不会报错，只是所有抓取点都偏。
-     yaw=0：倾斜方向就是 +x。水平方向的偏差（绕竖直轴）**地面拟合法永远标不
-     出来** —— 一个水平面绕自己的法向转多少度都还是它自己。要标 yaw 得用已知
-     位置的物体：把方块放在一个量好的点上，反解方位角。 -->
+     2026-10-20 用四个已知位置的方块把位姿**解**出来了，不是手量的：
+     方块放在 (0, +0.31)、(+0.10, +0.31)、(0, +0.21)、(0, +0.41)（米，相对
+     base_link 原点），每个位置记下节点日志里的"绿斑中心 (u, v)"，再用
+     "像素 → 去畸变射线 → 落地面 → 减影子偏置 = 真实位置" 做最小二乘，
+     解出位置和两个角。四个点残差 RMS 8.4 mm；用解出来的位姿做正向仿真，
+     四个点算出的坐标与真值差都在 1 mm 以内。
+     注意：2026-10-19 那次"按一个点把 x/y 各推 2 cm"的校正被这次取代了，
+     而且那次本身就是错的 —— 三组数据摆出来只有 0.36 倍的压缩，说明差的
+     不是一个平移，里面还压着一个角度错。 -->
+<xacro:property name="camera_offset_x" value="-0.302"/>
+<xacro:property name="camera_offset_y" value="0.317"/>
+<xacro:property name="camera_offset_z" value="0.097"/>
+<!-- 相机安装姿态（度）。位置和角度都是上面那四个点解出来的。
+     高度 0.097 比卷尺换算的 0.12 低 2 cm，这是单目固有的"高度 ↔ 俯角"
+     退让：同一组像素可以用"更低更平"或"更高更陡"两组参数解释，在
+     0.2~0.4 m 的工作范围里两者算出的点是同一处。所以这组数先用着；
+     要把高度定死，只能靠手眼标定（相机看得见机械臂末端在动）。
+     俯角 4.44°、yaw -1.32°：这两个角以前靠深度拟合地面来定，但地面拟合
+     只能给倾角、**永远给不出 yaw**（一个水平面绕自己的法向转多少度都还是
+     它自己），而且现场深度在 0.34 m 上没有回波。现在用已知位置的方块解，
+     两个角一起出来了。
+     写错位置会怎样：这个角必须写在 **pitch** 上 —— camera_link 的 +x 才是
+     镜头方向（orbbec 驱动把光学系的 z 指向 camera_link 的 +x），绕 y 轴转
+     pitch 时 +x 变成 (cos pitch, 0, -sin pitch)；写成 roll 的话镜头只在
+     yz 平面里动，方向完全不同，而且不会报错，只是所有抓取点都偏。 -->
 <xacro:property name="camera_mount_roll_deg" value="0"/>
-<xacro:property name="camera_mount_pitch_deg" value="33.3"/>
-<xacro:property name="camera_mount_yaw_deg" value="0"/>
+<xacro:property name="camera_mount_pitch_deg" value="4.44"/>
+<xacro:property name="camera_mount_yaw_deg" value="-1.32"/>
 <link name="camera_link"/>
 <joint name="camera_link_joint" type="fixed">

Commit message: fix: 按实测重建夹爪几何 —— URDF 的手指比实物长 100 mm，规划一开碰撞就失败
MoveIt 报 Unable to sample any valid states for goal tree，根因不是 OMPL 参数：
按旧的 tcp_offset_y=15 mm 建的 URDF 手指尖在 link7 端面 116.5 mm 处，比实物长
约 100 mm，抓取点 z=-0.029 时整只手埋进地面碰撞体，目标树里采不到合法状态。
之前"规划成功"是因为规划器不知道脚下有地面；87589f6 加地面盒只是把这个早就
存在的模型错误暴露出来。

2026-10-21 尺量：腕部→指尖 130 mm（80 mm 舵机/驱动板本体 + 50 mm 手指，手指里
15 mm 是滑动结构、35 mm 是夹取段），夹取中心在夹取段中点 ⇒ 离腕部
130 - 17.5 = 112.5 mm。据此：

- dummy2_urdf.xacro：tcp_offset_y 由 gripper_wrist_to_tip_m - gripper_tip_to_centre_m
  算出来（0.1125）；dummy_hand_v1_1 与两指的可视/碰撞几何从原作者 mesh 换成
  简化盒体（90x80x50 mm 本体、8x50x25 mm 指板），手指关节行程改成半个开口
  （0.0275），q=0 是两指内侧面接触、q=0.0275 是 55 mm 全开。
- dummy2.srdf：open 组状态的手指值跟着改成 0.0275。
- planner.plan_grasp()：夹持中心要抬高 fingertip_clearance + 指长/2 - 半边长
  = 8.5 mm，否则 17.5 mm 长的指头插进桌面；顺带加了"开口超过实测最大开口就拒"
  的检查，GraspPlan.tcp_offset_m 把这个抬高量记下来。
- scene_objects：地台按实测改成两层（和底座同大的 1 cm 上层 + 20x20x1.5 cm、
  中心在 +y 4 cm 的下层），1 mm 的缝从上层扣，下层底面正好落在工作面上。
- 三个自测同步更新，交叉检查 xacro 的两个分量与代码里的实测值一致。

A1 现在只剩「手指宽度 25 mm（占位）」与「角度↔开口映射（没量）」两项。

File: dummy_vc_ws/src/dummy2_urdf/urdf/dummy2_urdf.xacro (robot description, xacro)
@@ -14,11 +14,32 @@
 <!-- 手指伸出的方向：URDF 里手爪挂在 link7 的 +y 方向 -->
 <xacro:property name="hand_axis" value="y"/>
-<!-- link7 -> 两指夹持中心(指尖前端中点)，沿 hand_axis 的距离。
-     实测：2026-10-16 尺量，约 15 mm。
-     注意它比 hand 关节的 0.052312 还小，所以 gripper_tcp 落在 hand 坐标系
-     原点的**后方**（y = 0.015 - 0.052312 = -0.037312，即比 hand 原点更靠近
-     link7）—— 实物手爪的两指是贴着腕部夹的。URDF 里那套手指几何来自原作者
-     模型、与实物不符（docs/04 A1），两者不能互相印证。 -->
-<xacro:property name="tcp_offset_y" value="0.015"/>
+<!-- 实物夹爪的实测几何（2026-10-21 用尺子在整机上量的）。
+     ==========================================================
+     腕部(link7 端面) -> 指尖            130 mm
+       其中 80 mm 是舵机 + 驱动板 + 导轨那些不动的结构
+       剩下 50 mm 是可开合的手指（15 mm 滑动结构 + 35 mm 真正夹取段）
+     夹取中心 = 35 mm 夹取段的中点，离指尖 17.5 mm
+              => 离腕部 130 - 17.5 = 112.5 mm
+     最大开口（两指内侧面之间）         55 mm
+     单指板厚：三角截面，最厚 10 mm、最薄约 3 mm，这里按 8 mm 的均值
+     指尖宽度：这次没量，先按 25 mm 占位
+     之前这里写的是 15 mm —— 那次量的不是夹取中心（从照片和 130 mm 的
+     总长看，量到的是夹爪本体的某个面），已作废。这个数是 A1 的修复：
+     URDF 原来用的是原作者通用夹爪的网格，指尖落在腕部以下 116 mm，比
+     实物长了约 100 mm —— 于是一开碰撞检查，抓取位姿就整只手埋进桌面，
+     MoveIt 报 "Unable to sample any valid states for goal tree"。 -->
+<xacro:property name="gripper_wrist_to_tip_m" value="0.130"/>
+<xacro:property name="gripper_body_y_m" value="0.080"/>
+<xacro:property name="gripper_finger_y_m" value="0.050"/>
+<xacro:property name="gripper_tip_to_centre_m" value="0.0175"/>
+<xacro:property name="gripper_open_gap_m" value="0.055"/>
+<xacro:property name="gripper_finger_thick_m" value="0.008"/>
+<xacro:property name="gripper_finger_width_m" value="0.025"/>
+<xacro:property name="gripper_body_x_m" value="0.090"/>
+<xacro:property name="gripper_body_z_m" value="0.050"/>
+<!-- 半行程 = 一指从全闭到全开走多远 -->
+<xacro:property name="gripper_finger_travel_m" value="${gripper_open_gap_m/2}"/>
+<!-- link7 端面 -> 两指夹持中心（gripper_tcp 就放在这里） -->
+<xacro:property name="tcp_offset_y" value="${gripper_wrist_to_tip_m - gripper_tip_to_centre_m}"/>
 <!-- 相机的安装参数（外置支架，eye-to-hand）定义在文件末尾的相机段落里，
      因为那里有较长的说明。用 grep 搜 camera_offset 可以找到。 -->
@@ -181,15 +202,18 @@
     <inertia ixx="1.6e-05" iyy="0.000181" izz="0.000168" ixy="0.0" iyz="-0.0" ixz="-5e-06"/>
   </inertial>
-  <visual>
-    <origin xyz="-0.012149 -0.316832 -0.345967" rpy="0 0 0"/>
-    <geometry>
-      <mesh filename="file://$(find dummy2_urdf_description)/meshes/dummy_hand_v1_1.stl" scale="0.001 0.001 0.001"/>
-    </geometry>
-    <material name="silver"/>
-  </visual>
-  <collision>
-    <origin xyz="-0.012149 -0.316832 -0.345967" rpy="0 0 0"/>
-    <geometry>
-      <mesh filename="file://$(find dummy2_urdf_description)/meshes/dummy_hand_v1_1.stl" scale="0.001 0.001 0.001"/>
+  <!-- 手掌/舵机本体：用实测尺寸的盒体，不用原作者网格（见文件上方 A1 注释）。
+       本体从腕部往指尖方向占 80 mm，所以盒心在 hand 坐标系
+       y = 80/2 - 52.312 = -12.3 mm。 -->
+  <visual>
+    <origin xyz="0 ${gripper_body_y_m/2 - 0.052312} 0" rpy="0 0 0"/>
+    <geometry>
+      <box size="${gripper_body_x_m} ${gripper_body_y_m} ${gripper_body_z_m}"/>
+    </geometry>
+    <material name="silver"/>
+  </visual>
+  <collision>
+    <origin xyz="0 ${gripper_body_y_m/2 - 0.052312} 0" rpy="0 0 0"/>
+    <geometry>
+      <box size="${gripper_body_x_m} ${gripper_body_y_m} ${gripper_body_z_m}"/>
     </geometry>
   </collision>
@@ -201,15 +225,17 @@
     <inertia ixx="2.7e-05" iyy="2.2e-05" izz="4.2e-05" ixy="7e-06" iyz="-3e-06" ixz="3e-06"/>
   </inertial>
-  <visual>
-    <origin xyz="0.036579 -0.320832 -0.335365" rpy="0 0 0"/>
-    <geometry>
-      <mesh filename="file://$(find dummy2_urdf_description)/meshes/dummy_leftfinger_v1_1.stl" scale="0.001 0.001 0.001"/>
-    </geometry>
-    <material name="silver"/>
-  </visual>
-  <collision>
-    <origin xyz="0.036579 -0.320832 -0.335365" rpy="0 0 0"/>
-    <geometry>
-      <mesh filename="file://$(find dummy2_urdf_description)/meshes/dummy_leftfinger_v1_1.stl" scale="0.001 0.001 0.001"/>
+  <!-- 指板：盒心就是 link 原点（关节 origin 已经把它摆到正确位置）。
+       x 是板厚（沿开合方向）、y 是指板长度、z 是宽度。 -->
+  <visual>
+    <origin xyz="0 0 0" rpy="0 0 0"/>
+    <geometry>
+      <box size="${gripper_finger_thick_m} ${gripper_finger_y_m} ${gripper_finger_width_m}"/>
+    </geometry>
+    <material name="silver"/>
+  </visual>
+  <collision>
+    <origin xyz="0 0 0" rpy="0 0 0"/>
+    <geometry>
+      <box size="${gripper_finger_thick_m} ${gripper_finger_y_m} ${gripper_finger_width_m}"/>
     </geometry>
   </collision>
@@ -221,15 +247,16 @@
     <inertia ixx="2.7e-05" iyy="2.2e-05" izz="4.2e-05" ixy="-7e-06" iyz="3e-06" ixz="3e-06"/>
   </inertial>
-  <visual>
-    <origin xyz="-0.061406 -0.320832 -0.356601" rpy="0 0 0"/>
-    <geometry>
-      <mesh filename="file://$(find dummy2_urdf_description)/meshes/dummy_rightfiger_v1_1.stl" scale="0.001 0.001 0.001"/>
-    </geometry>
-    <material name="silver"/>
-  </visual>
-  <collision>
-    <origin xyz="-0.061406 -0.320832 -0.356601" rpy="0 0 0"/>
-    <geometry>
-      <mesh filename="file://$(find dummy2_urdf_description)/meshes/dummy_rightfiger_v1_1.stl" scale="0.001 0.001 0.001"/>
+  <!-- 同 dummy_leftfinger_v1_1。 -->
+  <visual>
+    <origin xyz="0 0 0" rpy="0 0 0"/>
+    <geometry>
+      <box size="${gripper_finger_thick_m} ${gripper_finger_y_m} ${gripper_finger_width_m}"/>
+    </geometry>
+    <material name="silver"/>
+  </visual>
+  <collision>
+    <origin xyz="0 0 0" rpy="0 0 0"/>
+    <geometry>
+      <box size="${gripper_finger_thick_m} ${gripper_finger_y_m} ${gripper_finger_width_m}"/>
     </geometry>
   </collision>
@@ -328,26 +355,23 @@
 </joint>
 <joint name="dummy2_finger_joint1" type="prismatic">
-  <origin xyz="-0.048728 0.004 -0.010602" rpy="0 0 0"/>
+  <origin xyz="${-gripper_finger_thick_m/2} ${gripper_body_y_m + gripper_finger_y_m/2 - 0.052312} 0" rpy="0 0 0"/>
   <parent link="dummy_hand_v1_1"/>
   <child link="dummy_leftfinger_v1_1"/>
-  <axis xyz="1.0 -0.0 0.000761"/>
+  <axis xyz="-1 0 0"/>
   <!--
-    ⚠ 下面的行程 (0~0.023 m) 和整个夹爪几何都来自**原作者的通用夹爪模型**，
-    与实物不符。实物是舵机 + 齿轮齿条 + 两条直线导轨 + 两个打印长手指。
-    这一项记录在本机的 docs/04（A1）。差异有几十毫米，对抓取精度是
-    致命的。
-    重建时要一起改：这里、dummy2_finger_joint2、gripper_tcp 的 origin
-    （真实抓取中心）、以及 MoveIt 的 config/dummy2.srdf 里 gripper 组与
-    open/closed 组状态。只改 mesh 不够。
+    行程 27.5 mm = 最大开口 55 mm 的一半，q=0 时两指内侧面刚好接触（全闭），
+    q=27.5 mm 时开口 55 mm（全开）。原来的 0~0.023 与整个夹爪几何都来自
+    原作者的通用夹爪模型，与实物不符（本机 docs/04 的 A1），已按实测重建。
+    SRDF 里 gripper 组的 open/closed 组状态用的是同一个数，改这里要一起改。
   -->
-  <limit upper="0.023" lower="0.0" effort="100" velocity="100"/>
+  <limit upper="${gripper_finger_travel_m}" lower="0.0" effort="100" velocity="100"/>
 </joint>
 <joint name="dummy2_finger_joint2" type="prismatic">
-  <origin xyz="0.049257 0.004 0.010634" rpy="0 0 0"/>
+  <origin xyz="${gripper_finger_thick_m/2} ${gripper_body_y_m + gripper_finger_y_m/2 - 0.052312} 0" rpy="0 0 0"/>
   <parent link="dummy_hand_v1_1"/>
   <child link="dummy_rightfiger_v1_1"/>
-  <axis xyz="-1.0 0.0 -0.000761"/>
-  <!-- 同 dummy2_finger_joint1：行程与几何与实物不符，见本机 docs/04 的 A1。 -->
-  <limit upper="0.023" lower="0.0" effort="100" velocity="100"/>
+  <axis xyz="1 0 0"/>
+  <!-- 同 dummy2_finger_joint1，两指沿相反方向同步开合。 -->
+  <limit upper="${gripper_finger_travel_m}" lower="0.0" effort="100" velocity="100"/>
 </joint>
 <!-- ==========================================================================
